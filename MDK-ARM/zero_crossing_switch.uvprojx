# Keil uVision project zero_crossing_switch.uvprojx, settings and files
target zero_crossing_switch (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C6 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x200027FF) IROM(0x8000000-0x8007FFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: zero_crossing_switch +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103x6
  c include: ../Inc;  ../Drivers/STM32F1xx_HAL_Driver/Inc;  ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;  ../Drivers/CMSIS/Device/ST/STM32F1xx/Include;  ../Drivers/CMSIS/Include;  ../Inc/led;  ../Inc/modbus;  ../Inc/switch;  ../Inc/memory;  ../Inc/memory/at24c512;  ../Inc/oil_temp
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group Application/MDK-ARM
    ./: startup_stm32f103x6.s
  group Application/User
    ../Src/: task.c comm_uart_callback.c crc.c delay.c main.c gpio.c i2c.c iwdg.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
    ../Src/led/: led.c
    ../Src/modbus/: modbus_interface.c modbus.c
    ../Src/memory/: memory.c
    ../Src/memory/at24c512/: at24c512.c
    ../Src/oil_temp/: oil_temp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group switch
    ../Src/switch/: switch.c
  group test_circle
    ../Src/test_circle/: switch.c
target zero_crossing_switch_test_circle (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C6 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: zero_crossing_switch_test +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103x6
  c include: ../Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../Inc/led;../Inc/oil_temp;../Inc/memory;../Inc/memory/at24c512;../Inc/switch;../Inc/modbus
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2800
software components: CMSIS:CORE 4.3.0
